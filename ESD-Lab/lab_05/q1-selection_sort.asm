	AREA RESET, DATA, READONLY
	EXPORT __Vectors
	
__Vectors
	DCD 0X10000000
	DCD Reset_Handler
	ALIGN
	AREA mycode, CODE, READONLY
	ENTRY
	EXPORT Reset_Handler
	
Reset_Handler
	LDR R0,=ARR
	MOV R8,#4 ;n-1
UP1 MOV R7,R8
	MOV R1,R0
UP2 LDR R2,[R0]
	LDR R3,[R1,#4]!
	CMP R3,R2
	BLS SKIP
	STR R2,[R1]
	STR R3,[R0]
SKIP 
	SUB R7,#01
	TEQ R7,#0
	BNE UP2
	
	ADD R0,#4
	SUB R8,#1
	TEQ R8,#0
	BNE UP1

STOP
	B STOP

	AREA data,DATA 
ARR	DCD 0,0,0,0,0,0 ; PUT NUMBERS DIRECTLY INTO THE MEMORY
	END
